FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://syslog-ng.conf.patch"

