FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://syslog-ng-3.6.4.conf.patch"

